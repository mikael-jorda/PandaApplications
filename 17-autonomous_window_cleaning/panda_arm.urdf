Commit message: window cleaning tested on robot

File: 17-autonomous_window_cleaning/panda_arm.urdf (robot description, URDF)
Before this commit: robot panda, 8 links, 7 joints
Links:
- link link7: geometry collision cylinder length=0.15 radius=0.008; visual cylinder length=0.04 radius=0.045
